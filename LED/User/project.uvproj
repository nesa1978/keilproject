# Keil uVision project project.uvproj, settings and files
target project (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User;..\Driver
  group User
    ./: main.c
  group Driver
    ../Driver/: key.c key.h led.c led.h seg.c seg.h sys_init.c sys_init.h
